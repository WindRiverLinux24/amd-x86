EXTRA_OECONF:append:virtclass-multilib-lib32:amd-x86 = " --disable-cet"
