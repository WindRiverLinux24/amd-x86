require linux-yocto-amd-x86.inc

KBRANCH:amd-x86  = "v6.6/standard/preempt-rt/x86"
