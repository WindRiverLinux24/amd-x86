require linux-yocto-amd-x86.inc

KBRANCH:amd-x86  = "v5.15/standard/preempt-rt/x86"
