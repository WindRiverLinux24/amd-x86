require linux-yocto-amd-x86.inc

KBRANCH:intel-x86  = "v6.1/standard/x86"
